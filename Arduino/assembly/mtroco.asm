JMP MAIN
NUMBER:
 DB 254 

MAIN:
 PUSH 1
 PUSH 10
 PUSH 100
 MOV B,[NUMBER]
 MOV D,232
LOOP1:
 POP A
LOOP:
  
 SUB    ,A
 JC SEILA
 INC C
 JMP LOOP
SEILA:
 ADD B,A
 CALL PRINT
 JMP LOOP1
PRINT:
 ADD C,48
 MOV [D],C
 INC D
 MOV C,0
 RET